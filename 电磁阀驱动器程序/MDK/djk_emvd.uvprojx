# Keil uVision project djk_emvd.uvprojx, settings and files
target dyk-emvd (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: djk_emvd +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10x_MD,BOOTLOADER_ENABLED1,IWDG_ENABLED
  c include: ..\LIB\CM3;..\LIB\STM32F10x_StdPeriph_Driver\inc;..\USER;..\LIB;..\BSP;..\USER\Logic;..\USER\Driver
  memory RVCT4: ROM 0x8004000 size 0x117ff
  memory RVCT9: RAM 0x20000000 size 0x5000
  group StdPeriph_Driver
    ../LIB/CM3/startup/: startup_stm32f10x_md.s
  group STM32F10x_StdPeriph_Driver
    ../LIB/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_can.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_iwdg.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_usart.c stm32f10x_tim.c
  group STM32F10x_CM3
    ../LIB/CM3/: core_cm3.c
  group BSP
    ../BSP/: Bsp.c
  group Drive
    ../LIB/CM3/: system_stm32f10x.c
    ../USER/Driver/: Can_Driver.c OutPoint.c Adc_Driver.c iwdg.c Hard_Id.c GpioConfig.c
  group Logic
    ../USER/Logic/: Can_Pro.c CanIap.c iapupdate.c RegularCheck.c
  group User
    ../USER/: main.c stm32f10x_it.c stm32f10x_it.h stm32f10x_conf.h includes.h
